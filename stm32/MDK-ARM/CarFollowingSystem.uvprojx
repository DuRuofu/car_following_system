# Keil uVision project CarFollowingSystem.uvprojx, settings and files
target CarFollowingSystem (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: CarFollowingSystem +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Users/App;../Users/Components/key;../Users/Components/led;../Users/Components/oled;../Users/Components/usart;../Users/Components/motor;../Users/Components/encoder;../Users/Components/pid;../Users/Components/buzzer;../Users/Components/PWM;../Users/Components/YunTai
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User
    ../Users/App/: app.c
    ../Users/Components/key/: key.c
    ../Users/Components/led/: led.c
    ../Users/Components/oled/: oled.c
    ../Users/Components/usart/: uart_it_config.c uart_1.c uart_2.c
    ../Users/Components/ENCODER/: encoder.c
    ../Users/Components/MOTOR/: motor.c
    ../Users/Components/PID/: pid.c
    ../Users/Components/buzzer/: buzzer.c
    ../Users/Components/PWM/: pwm.c
    ../Users/Components/YunTai/: yuntai.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.0.1
